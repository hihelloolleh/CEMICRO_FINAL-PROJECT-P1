# Repository hihelloolleh/CEMICRO_FINAL-PROJECT-P1

File README.md:

To run the program:
  1. .\asm11_win32 FINALPROJ.ASM (Make sure that this has 0 warning(s) and 0 error(s))
  2. .\asm11_win32 -l FINALPROJ.ASM (Make sure that this has 0 warning(s) and 0 error(s))
  3. python3 HC11_FPROJ.py -c COM3 -i FINALPROJ.s19

## KiCad design KiCad/EPROM_Prog_PS.kicad_pcb

Parts:
C1: 4.7uF 25V; CP_Radial_D5.0mm_P2.00mm
C2: 100uF 16V; CP_Radial_D6.3mm_P2.50mm
C3: 0.22uF 50V; C_Disc_D6.0mm_W4.4mm_P5.00mm
D1: Power_Ind; LED_D5.0mm
D2: Prog_Ind; LED_D5.0mm
D3, D4: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
D5, D6: 1N34A; D_DO-35_SOD27_P7.62mm_Horizontal
J1: 12.5Vdc_In; PinHeader_1x02_P2.54mm_Vertical
J2: Prog_EN; PinHeader_1x02_P2.54mm_Vertical
J3: Vpp_Vcc_Out; PinHeader_1x03_P2.54mm_Vertical
Q1: SST3904; SOT-23
Q2: TM2301GN; SOT-23
R1, R4, R5: 2.7K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2, R3, R8: 3.3K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R6, R9: 1.3K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R7, R10: 820; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1: LM317L_TO92; TO-92_Inline

Connections:
GND: C1.2, C2.2, C3.2, J1.2, J2.2, J3.2, Q1.2 (E), R4.2, R5.2, R7.2, R8.2, R10.2
unnamed: C1.1, D1.2 (A), D5.2 (A), D6.2 (A), J3.3, R6.1, U1.2 (VO)
unnamed: D1.1 (K), R10.1
unnamed: D2.2 (A), D4.1 (K)
unnamed: D2.1 (K), D3.1 (K), R8.1
unnamed: D3.2 (A), R7.1, R9.1, U1.1 (ADJ)
unnamed: C3.1, D4.2 (A), D5.1 (K), D6.1 (K), J3.1, Q2.3 (D), R5.1
unnamed: C2.1, J1.1, Q2.2 (S), R1.1, U1.3 (VI)
unnamed: J2.1, R3.1
unnamed: Q1.1 (B), R3.2, R4.1
unnamed: Q1.3 (C), R2.2
unnamed: Q2.1 (G), R1.2, R2.1
unnamed: R6.2, R9.2

Notes on the sheet:
Green
Vpp 5V / 13V GND Vcc 5V / 6V
GND
Red

Board: 2 copper layers, 60.0 x 80.0 mm, 25 parts (2 on the bottom side), 13 nets.

## Commit log

2025-11-19 Adding Files from the Computer
    tapos na yippiee
2025-11-19 How to run the program
2025-11-21 added printing ASCII
2025-11-21 Picture for proof
2025-12-02 Create hi
2025-12-02 Upload KiCad
2025-12-03 PCB Design
2025-12-03 Fixed track width errors
2025-12-03 PCB: increased dimension
2025-12-04 Add initial EPROM read/write assembly code
    not yet final. need to check things with writing code
2025-12-04 move file from KiCad to PART-2 branch
2025-12-04 dump
2025-12-04 updated asm code
2025-12-05 2nd draft
2025-12-05 python code for part 2 (NOT FINAL)
2025-12-05 python code for part 2 (NOT YET FINAL)
2025-12-05 edit smth
2025-12-05 change ser.timeout to 30
2025-12-06 latest
